# Keil uVision project MS-JTv3 - uV5.uvproj, settings and files
target BIG8051 (MCS-51)
  device: C8051F040 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: MSv1
  c flags: Optimize=8 SizeSpeed=1
  c include: .\BIG8051\Include
  group Drivers
    ./BIG8051/Drivers/: osc.c wdt.c port.c timer.c uart0.c uart1.c lcd.c keyb.c
  group Application
    ./: TxMesajV3.c RxMesajV3.c UserIO.c MS.c JT.c
